# Keil uVision project project.uvprojx, settings and files
target Nucleo-F091RC (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F091,USE_STDPERIPH_DRIVER,KEIL_IDE,TM_DISCO_NUCLEO_F091
  c include: .\User;.\TM;..\00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS\STM32F0xx_StdPeriph_Driver\inc;..\00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS\STM32F0xx_StdPeriph_Driver\src;..\00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS\STM32F0xx_CPAL_Driver\inc;..\00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS\STM32F0xx_CPAL_Driver\src;..\00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F0xx\Include;..\00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm;..\00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\00-STM32F0xx_LIBRARIES
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h system_stm32f0xx.h
  group Startup
    ../00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f091.s startup_stm32f072.s startup_stm32f030.s startup_stm32f070xb.s
  group STD_Periph_Drivers
    ../00-STM32F0xx_STANDARD_PERIPHERAL_DRIVERS/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_misc.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c
  group TM
    ../00-STM32F0xx_LIBRARIES/: tm_stm32f0_delay.c tm_stm32f0_delay.h tm_stm32f0_disco.c tm_stm32f0_disco.h tm_stm32f0_gpio.h tm_stm32f0_gpio.c tm_stm32f0_usart.c tm_stm32f0_usart.h
  group User
    ./User/: main.h main.c defines.h stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h system_stm32f0xx.c
target Nucleo-F072RB (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F072xB,USE_STDPERIPH_DRIVER,KEIL_IDE,TM_DISCO_NUCLEO_F072
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target Nucleo-F070RB (ARM-ADS)
  device: STM32F070RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: project +hex
  c flags: Optim=1
  c define: STM32F070xB,USE_STDPERIPH_DRIVER,KEIL_IDE,TM_DISCO_NUCLEO_F070
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target Nucleo-F030R8 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F030,USE_STDPERIPH_DRIVER,KEIL_IDE,TM_DISCO_NUCLEO_F030
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target STM32F030-Discovery (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: project +hex
  c flags: Optim=1
  c define: STM32F030,USE_STDPERIPH_DRIVER,KEIL_IDE,TM_DISCO_STM32F030_DISCOVERY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target STM32F072-Discovery (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: project +hex
  c flags: Optim=1
  c define: STM32F072xB,USE_STDPERIPH_DRIVER,KEIL_IDE,TM_DISCO_STM32F072_DISCOVERY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
